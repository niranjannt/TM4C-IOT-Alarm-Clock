# Keil uVision project Lab4.uvprojx, settings and files
target Lab 4 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab4 +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ./..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: Lab4E_Main.c startup.s UART.c Lab4E_Main.h
    ../../../lab-3-nnt-tt/sw/src/: LED.c Sound.c Switch.c Systick.c Timer1A.c LCD.h LED.h Sound.h Switch.h Timer1A.h
  group inc
    ../inc/: PLL.c Unified_Port_Init.c Timer0A.c Timer2A.c ST7735.c MQTT.c esp8266_base.c UART5.c Timer5A.c
    ./: FIFO3.h globals.h
